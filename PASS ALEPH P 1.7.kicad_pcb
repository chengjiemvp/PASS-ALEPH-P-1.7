# Repository chengjiemvp/PASS-ALEPH-P-1.7

## KiCad design PASS ALEPH P 1.7.kicad_pcb

Parts:
C1, C2, C15, C16: 680PF; B83C681JN1B0120090050EOY
C3, C4, C5, C6, C11, C12, C13, C14: 10UF; MKP20106J2EAC461625-扁形
C7, C9: 100NF; MES104J2A-7-50R0
C8, C10: 10000UF; DL80VN10000M35_50 VN
CN1: 2线焊盘
CN2, CN3: 3线焊盘
D1: LED; LED_1206
Q2, Q9: BCX53-16,115; BCP53-16,115
Q3, Q4, Q7, Q8: IRF610PBF
Q5, Q6: IRF9610PBF
Q11, Q12: BCP56-16,115
R1, R2, R16, R22, R36, R37: 10K; R_MELF_0207
R3, R34: 3.32K; R_1206
R4, R18, R21, R35: 100; R_MELF_0207
R5, R33: 22.1K; R_1206
R6, R17, R20, R32: 4.75K; R_1206
R7, R12, R25, R31: 221K; R_1206
R8, R9, R10, R11, R13, R26, R27, R28, R29, R30: 221; R_1206
R14, R23: 22; R_MELF_0207
R15, R24: 33; R_MELF_0207
R19: 2K; R_2512
R38: 3.3; R_MELF_0207
R39: 5K; R_1206
Z1, Z2, Z3, Z4: 1SMB5924BT3G

Connections:
/IN+: CN2.1 (IN+), R1.2
/IN-: CN2.3 (IN-), R37.1
/OUT+: CN3.1 (OUT+), R35.2
/OUT-: CN3.3 (OUT-), R4.2
/VCC: CN1.1 (VCC), D1.2 (A), R38.1
GND: C2.2, C7.1, C8.2, C9.1, C10.2, C16.1, CN1.2 (GND), CN2.2 (GND), CN3.2 (GND), Q11.3 (E), Q12.3 (E), R3.1, R5.1, R6.2, R7.1, R15.2, R16.1, R17.1, R20.1, R22.1, R24.2, R31.1, R32.1, R33.1, R34.1, R39.2, Z2.1 (K), Z4.1 (K)
unnamed: C2.1, C4.2, C5.2, C6.2, R4.1, R6.1
unnamed: C3.2, R7.2, R12.2, R13.1
unnamed: C11.1, C12.1, C13.1, C16.2, R32.2, R35.1
unnamed: C14.1, R25.1, R26.2, R31.2
unnamed: D1.1 (K), R39.1
unnamed: Q2.1 (B), R8.1
unnamed: C1.2, Q2.2 (C), R2.2, R9.1
unnamed: C1.1, C7.2, C8.1, C9.2, C10.1, C15.1, Q2.3 (E), Q9.3 (E), R14.1, R23.1, R38.2
unnamed: C4.1, C5.1, C6.1, Q3.2 (D), Q5.2 (D), R12.1, R16.2, R17.2
unnamed: Q3.1 (G), R13.2
unnamed: Q3.3 (S), Q4.2 (D), R18.1
unnamed: Q4.1 (G), R10.2
unnamed: Q4.3 (S), R11.2, R15.1
unnamed: Q5.1 (G), R9.2
unnamed: Q5.3 (S), R8.2, R14.2
unnamed: C11.2, C12.2, C13.2, Q6.2 (D), Q7.2 (D), R20.2, R22.2, R25.2
unnamed: Q6.1 (G), R28.1
unnamed: Q6.3 (S), R23.2, R27.1
unnamed: Q7.1 (G), R26.1
unnamed: Q7.3 (S), Q8.2 (D), R21.1
unnamed: Q8.1 (G), R29.1
unnamed: Q8.3 (S), R24.1, R30.1
unnamed: Q9.1 (B), R27.2
unnamed: C15.2, Q9.2 (C), R28.2, R36.1
unnamed: Q11.1 (B), R11.1
unnamed: Q11.2 (C), R2.1, R10.1
unnamed: Q12.1 (B), R30.2
unnamed: Q12.2 (C), R29.2, R36.2
unnamed: R18.2, R19.1
unnamed: R19.2, R21.2
unnamed: Z1.2 (A), Z2.2 (A)
unnamed: C3.1, R1.1, R3.2, R5.2, Z1.1 (K)
unnamed: Z3.2 (A), Z4.2 (A)
unnamed: C14.2, R33.2, R34.2, R37.2, Z3.1 (K)

Notes on the sheet:
装0欧姆

Board: 6 copper layers, 200.0 x 100.0 mm, 74 parts (0 on the bottom side), 40 nets.

Other parts of the board:
JJC***: LOGO

## Commit log

2025-10-01 2 layer-board, background noise
2025-10-03 6 layer-board, layout finished
2025-10-03 replace some film resistor, fix some bug
2025-10-03 second power ground, split ground plane
2025-10-03 fix some bug
2025-10-05 split some gnd pin, fix some bug
2025-10-05 fix some bugs
2025-10-05 use smd led
